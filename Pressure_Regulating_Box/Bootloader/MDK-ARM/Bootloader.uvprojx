# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (6240000::V6.24::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32L233
  c include: ..\..\..\GD32L23x_Firmware_Library\CMSIS\GD\GD32L23x\Include;..\..\..\GD32L23x_Firmware_Library\GD32L23x_standard_peripheral\Include;..\..\Projects\07_LPUART_Deepsleep_Wakeup\MDK-ARM\my_Library;.;..\..\Middle
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: boot_main.c
  group CMSIS
    ../../../GD32L23x_Firmware_Library/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
    ../../../GD32L23x_Firmware_Library/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l233.s
  group GD32L23x_Peripherals
    ../../../GD32L23x_Firmware_Library/GD32L23x_standard_peripheral/Source/: gd32l23x_fmc.c gd32l23x_gpio.c gd32l23x_misc.c gd32l23x_rcu.c gd32l23x_usart.c
software components: CMSIS:CORE 5.1.1
