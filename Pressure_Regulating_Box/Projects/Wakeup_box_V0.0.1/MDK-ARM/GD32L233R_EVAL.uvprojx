# Keil uVision project GD32L233R_EVAL.uvprojx, settings and files
target Integrated Pressure Regulating Box (6240000::V6.24::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin -o ".\Objects\Project.bin" ".\Objects\Project.axf"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32L233
  c include: ..\..\..\..\GD32L23x_Firmware_Library\CMSIS\GD\GD32L23x\Include;..\..\..\..\GD32L23x_Firmware_Library\GD32L23x_standard_peripheral\Include;..\..\..\Utilities;..\;..\..\..\App;..\..\..\Middle;..\..\..\BSP;..\..\..\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c gd32l23x_it.c systick.c
    ../../../App/: main.h
  group CMSIS
    ../../../../GD32L23x_Firmware_Library/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
  group GD32L23x_Peripherals
    ../../../../GD32L23x_Firmware_Library/GD32L23x_standard_peripheral/Source/: gd32l23x_adc.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_ctc.c gd32l23x_dac.c gd32l23x_dbg.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_fwdgt.c gd32l23x_gpio.c gd32l23x_i2c.c gd32l23x_lptimer.c gd32l23x_lpuart.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_rtc.c gd32l23x_slcd.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_usart.c gd32l23x_vref.c gd32l23x_wwdgt.c
  group Startup
    ../../../../GD32L23x_Firmware_Library/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l235.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.1.1
